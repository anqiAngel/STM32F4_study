# Keil uVision project template.uvprojx, settings and files
target template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\DEVICE_LIB\inc;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/: system_stm32f4xx.c stm32f4xx.h system_stm32f4xx.h
